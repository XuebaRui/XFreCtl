# Keil uVision project iSO-STM32.uvprojx, settings and files
target STM32_W5300 (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\User\SysTick;..\..\User\UART;..\..\User\sht11;..\..\User\DHT12;..\..\User\simple_delay;..\..\User\Zn200;..\..\User\SPI;..\..\User\CTL;..\..\User\RS232;..\..\User\hmc704;..\..\User\ZK;..\..\User\OLED;..\..\User\hmc832;..\..\User\func;..\..\User\ioport;..\..\User\internalflash;..\..\User\KEY;..\..\User\ADC
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x70000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h nvic_conf.c parser.c
    ../../User/Zn200/: BSP_ZN200.C
    ../../User/OLED/: oled.c bmp.h
    ../../User/ZK/: zk.c
    ../../User/simple_delay/: delay.c
    ../../User/func/: func.c
    ../../User/internalflash/: myflash.c
    ../../User/ioport/: ioport.c
    ../../User/KEY/: key.c key.h
    ../../User/SPI/: hard_spi.c
